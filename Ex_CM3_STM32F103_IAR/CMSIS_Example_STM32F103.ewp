# IAR project CMSIS_Example_STM32F103.ewp, settings and files
configuration MCBSTM32E (ARM, debug)
  General.OGChipSelectEditMenu: STM32F10xxE ST STM32F10xxE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: STM32F10X_HD; DATA_IN_ExtSRAM
  ICCARM.CCIncludePath2: ./CoreSupport; ./DeviceSupport/ST/STM32F10x; ../Boss; ../Ex_CM3_STM32F103_IAR
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: CMSIS_Test_STM32F103.srec
  ILINK.IlinkOutputFile: CMSIS_Example.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: Abstract.txt Boss_Conf.c main_STM32F103.c startup_stm32f10x_hd.s system_stm32f10x.c
    CoreSupport/: core_cm3.c
  group Boss
    ../Boss/: Boss_Kernel.c Boss_Mem.c Boss_Q_Mail.c Boss_Q_Msg.c Boss_Sem.c Boss_Tmr.c
    ../Boss_Port/: MCU_Cortex_M3_IAR.c MCU_Cortex_M3_IAR_asm.s
