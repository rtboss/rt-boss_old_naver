# Keil uVision project Boss_STM32F103.uvproj, settings and files
target Simulator (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: CMSIS_Example
  c flags: Optim=1
  c define: STM32F10X_HD DATA_IN_ExtSRAM
  c include: ./CoreSupport;./DeviceSupport/ST/STM32F10x;../Boss;./
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Boss
    ../Boss/: Boss_Kernel.c Boss_Sem.c Boss_Tmr.c Boss_Q_Mail.c Boss_Q_Msg.c Boss_Mem.c
    ../Boss_Port/: MCU_Cortex_M3_Keil.c
  group CMSIS files
    ./: startup_stm32f10x_hd.s system_stm32f10x.c
    ./CoreSupport/: core_cm3.c
  group Source files
    ./: Boss_Conf.c main_STM32F103.c
  group Documentation
    ./: Abstract.txt
target MCBSTM32E (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  cpu: as above
  output: CMSIS_Example
  c flags: Optim=1
  c define: STM32F10X_HD DATA_IN_ExtSRAM
  c include: ./CoreSupport;./DeviceSupport/ST/STM32F10x;../Boss;./
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
