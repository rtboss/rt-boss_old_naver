# Keil uVision project uV_STM32F103RB.uvproj, settings and files
target Simulator (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: uV_STM32F103RB
  c flags: Optim=1
  c define: STM32F10X_MD
  c include: .\;..\Boss
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Boss files
    ./: Boss_Conf.c
    ../Boss_Port/: Port_ARM_CM3_Keil.c
    ../Boss/: Boss.c Boss_Tmr.c Boss_Mem.c Boss_Q_Msg.c Boss_Q_MBox.c Boss_Sem.c
  group Source files
    ./: startup_stm32f10x_md.s system_stm32f10x.c
    ../: Main.c
