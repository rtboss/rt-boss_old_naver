# IAR project wIDE_STM32L152VB.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L151xB ST STM32L151xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: STM32L1XX_MD; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ; ..\Boss; Periph_Driver
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: wIDE_STM32L152VB.hex
  ILINK.IlinkOutputFile: wIDE_STM2L152VB.out
  ILINK.IlinkIcfFile: stm32l1xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Boss files
    ../Boss/: Boss.c Boss_Mem.c Boss_Q_MBox.c Boss_Q_Msg.c Boss_Sem.c Boss_Tmr.c
    ./: Boss_Conf.c
    ../Boss_Port/: Boss_CPU_ARM_CM3_IAR.c Boss_CPU_ARM_CM3_IAR_asm.s
  group Periph_Driver
    Periph_Driver/: stm32l1xx_gpio.c stm32l1xx_rcc.c stm32l1xx_usart.c
  group Source files
    ../: Main.c
    ./: startup_stm32l1xx_md.s system_stm32l1xx.c
